# Keil uVision project prj.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2294 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: prj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s DEBUG_HEADER.h I2C_COMMUNICATION.c I2C_COMMUNICATION.h lidar.c lidar.h main.c Retarget.c TIMER.c TIMER.h UART0.c UART0.h SONAR.c SONAR.h
